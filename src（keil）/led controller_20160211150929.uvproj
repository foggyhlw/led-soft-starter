# Keil uVision project led controller_20160211150929.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5616AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: led controller +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
